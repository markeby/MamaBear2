File: Mama Bear 2.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: Completed Schematics :
Other:
- added sheet Phono Preamp (PhonoPreamp.kicad_sch)
